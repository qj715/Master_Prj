# IAR project DISCOVER.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051R8 ST STM32F051R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: VECT_TAB_FLASH
  ICCARM.PreInclude: stm32f0xx_conf.h
  ICCARM.CCIncludePath2: ; src\EvalTest; ..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\Libraries\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DISCOVER.hex
  ILINK.IlinkOutputFile: DISCOVER.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Ram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SILICON_CHIP; VECT_TAB_RAM
  ILINK.IlinkIcfFile: stm32f0xx_ram.icf
  group EvBoard
    src/EvalTest/: main.c system_stm32f0xx.c
  group EWARM
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group include
    ./: main.h
  group Lib
    src/EvalTest/: stm32f0xx_exti.c stm32f0xx_it.c stm32f0xx_syscfg.c stm32f0xx_tim.c
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c
